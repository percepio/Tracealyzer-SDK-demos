# IAR project tz-sdk-demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F769II ST STM32F769II
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCIncludePath2: C:\src\tz-sdk-iar\TraceRecorder\config; C:\src\tz-sdk-iar\TraceRecorder\include; C:\src\tz-sdk-iar\TraceRecorder\streamports\File\config; C:\src\tz-sdk-iar\TraceRecorder\streamports\File\include; C:\src\tz-sdk-iar\CMSIS
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: main.c
  group TraceRecorder
    TraceRecorder/: trcAssert.c trcCounter.c trcDependency.c trcDiagnostics.c trcEntryTable.c trcError.c trcEvent.c trcEventBuffer.c trcExtension.c trcHardwarePort.c trcHeap.c trcInternalEventBuffer.c trcInterval.c trcISR.c trcKernelPort.c trcMultiCoreEventBuffer.c trcObject.c trcPrint.c trcRunnable.c trcSnapshotRecorder.c trcStackMonitor.c trcStateMachine.c trcStaticBuffer.c trcStreamingRecorder.c trcString.c trcTask.c trcTimestamp.c
  group TraceRecorder/config
    TraceRecorder/config/: trcConfig.h trcKernelPortConfig.h trcKernelPortSnapshotConfig.h trcKernelPortStreamingConfig.h trcSnapshotConfig.h trcStreamingConfig.h
  group TraceRecorder/StreamPortFile
    TraceRecorder/streamports/File/: trcStreamPort.c
    TraceRecorder/streamports/File/include/: trcStreamPort.h
    TraceRecorder/streamports/File/config/: trcStreamPortConfig.h
